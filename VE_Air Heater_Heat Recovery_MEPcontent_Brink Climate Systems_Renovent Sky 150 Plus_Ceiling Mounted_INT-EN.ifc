Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2018-06-28T08:03:54
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Jun 28 08:03:54 2018 * Host: B3ROBRAWR4425 * Database: C:\Users\DDA\AppData\Local\Temp\{A67F8E68-9C55-4E43-94D0-5D354FD09658}\ifc * Database version: 5507 * Database creation date: Thu Jun 28 08:03:53 2018 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Thu Jun 28 08:03:54 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Jun 28 08:03:54 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Other - Category: Project Information

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no; Type Name: Level 1
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcAirToAirHeatRecovery: Renovent Sky 150 Plus, VE_Air Heater_Heat Recovery_MEPcontent_Brink Climate Systems_Renovent Sky_150_Ceiling Mounted_FR-FR:Renovent Sky 150 Plus:38937
In: Level 1
Type - Material: Color RGB 062-062-062, Color RAL 9016, Color RGB 036-036-036, Color RAL 7045
Type - Dimensions - Height: 197.998 mm; Length: 999.988 mm; Width: 659.992 mm
Type - Electrical - Loads - Nominal Voltage: 230.002 V
Type - Identity Data - Article Description: Heat recovery unit; Article Type: Renovent Sky 150 Plus; Content Supplier URL: www.MEPcontent.com; Copyright: © Stabiplan International BV; Custom: no; Description: Heat recovery unit; EMCS Version: 4.0; ETIM Article Class: EC011285; Family Version: 11.17; GTIN: 8718391148561; Manufacturer: Brink Climate Systems; Manufacturer Art. No.: 423001; Manufacturer URL: www.brinkclimatesystems.nl/downloads_renovent-sky-150; MEPcontent Class: AIR_HEATER_HEAT_RECOVERY; Model: Renovent Sky 150 Plus; OmniClass Number: 23.75.70.17; OmniClass Title: Water Heated and Cooled Terminal Heating and Cooling Units; Product Line: Brink Climate Systems; Revit Version: 2017; Type Name: Renovent Sky 150 Plus; URL: www.stabiplan.com; Watermarked By: www.stabiplan.com
Type - Materials and Finishes - Black: Color RGB 036-036-036; Grey 1: Color RGB 062-062-062; Grey 2: Color RAL 7045; Service Area: Color RGB 218-227-224; White: Color RAL 9016
Type - Other - Category: Mechanical Equipment; Family Name: VE_Air Heater_Heat Recovery_MEPcontent_Brink Climate Systems_Renovent Sky_150_Ceiling Mounted_FR-FR
Pset_ManufacturerTypeInformation - Manufacturer: Brink Climate Systems
Constraints - Offset: 0 mm
Dimensions - Area: 2.91264 m2; Volume: 0.137526 m3
Electrical - Loads - Apparent Load: 0 W; Nominal Current: 0 A
Identity Data - Mark: 1
Mechanical - Drain Fixture Units: 0; Heating Power: 0; System Classification: Power,Sanitary,Supply Air,Exhaust Air,Supply Air,Return Air
Mechanical - Flow - Deflate Flow: 0 m3/s; Fresh Air Flow: 0 m3/s; Return Flow: 0 m3/s; Supply Flow: 0 m3/s
Other - Angle Condition: 180 deg; Family: VE_Air Heater_Heat Recovery_MEPcontent_Brink Climate Systems_Renovent Sky_150_Ceiling Mounted_FR-FR: Renovent Sky 150 Plus; Family and Type: VE_Air Heater_Heat Recovery_MEPcontent_Brink Climate Systems_Renovent Sky_150_Ceiling Mounted_FR-FR: Renovent Sky 150 Plus; Service Area Bottom: 0 mm; Service Area Height: 208 mm; Service Area Top: 0 mm; Service Area Width: 660 mm; Type: VE_Air Heater_Heat Recovery_MEPcontent_Brink Climate Systems_Renovent Sky_150_Ceiling Mounted_FR-FR: Renovent Sky 150 Plus; Type Id: VE_Air Heater_Heat Recovery_MEPcontent_Brink Climate Systems_Renovent Sky_150_Ceiling Mounted_FR-FR: Renovent Sky 150 Plus
Phasing - Phase Created: New Construction
Visibility - Ceiling Mounted: yes; Mounting Service Area: no; Show Service Area: no; Wall Mounted: no
